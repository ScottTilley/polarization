options:
  parameters:
    author: Scott Tilley
    description: An XY recorder inspired by Daniel Estevez
    generate_options: qt_gui
    id: XY_record_v1
    output_language: python
    run_options: run
    title: XY Recorder
  states: {}

blocks:
- name: decim1
  id: variable
  parameters:
    value: '16'
  states: {}
- name: decim2
  id: variable
  parameters:
    value: '32'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 60e6
    step: 1e6
    stop: 6e9
    value: 2237.36e6
  states: {}
- name: integ
  id: variable
  parameters:
    value: '1'
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: xx_out
  id: variable
  parameters:
    value: datetime.datetime.utcnow().isoformat().split('.')[0] + '.xx.f32'
  states: {}
- name: xy_out
  id: variable
  parameters:
    value: datetime.datetime.utcnow().isoformat().split('.')[0] + '.xy.c64'
  states: {}
- name: yy_out
  id: variable
  parameters:
    value: datetime.datetime.utcnow().isoformat().split('.')[0] + '.yy.f32'
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    buffers: '512'
    buflen: '4096'
    bw: 1e6
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: |
      e5dc5ef8d6be4d5fabe03f2927c1e4c4
    feature: default
    fpga_image: ''
    fpga_reload: 'False'
    freq: freq
    gain0: '60'
    gain1: '60'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '2'
    out_clk: 'False'
    ref_clk: 10e6
    sample_format: 16bit
    sample_rate: samp_rate
    sampling: internal
    show_pmic: 'False'
    smb: 38.4e6
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'False'
    verbosity: info
    xb200: none
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: xy_out
    type: complex
    vlen: nfft
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: xx_out
    type: float
    vlen: nfft
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: yy_out
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(samp_rate/decim1/nfft*integ)
    type: complex
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(samp_rate/decim1/nfft*integ)
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(samp_rate/decim1/nfft*integ)
    type: float
    vlen: nfft
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: nfft
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: decim1
    samp_rate: samp_rate
    taps: firdes.low_pass(1e-3, samp_rate, samp_rate/2, 25e3)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: decim1
    samp_rate: samp_rate
    taps: firdes.low_pass(1e-3, samp_rate,samp_rate/2, 25e3)
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import datetime
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate/decim1
    fc: freq+offset
    fftsize: '32768'
    type: complex
    ymax: '-100'
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"CH1"'
    type: complex
  states: {}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"CH2"'
    type: complex
  states: {}
- name: qtgui_sink_x_1_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decim1
    fc: '0'
    fftsize: '4096'
    name: '"CH1"'
    type: complex
  states: {}
- name: qtgui_sink_x_1_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decim1
    fc: '0'
    fftsize: '4096'
    name: '"CH1"'
    type: complex
  states: {}

connections:
- [bladeRF_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [bladeRF_source_0, '0', qtgui_sink_x_1, '0']
- [bladeRF_source_0, '1', freq_xlating_fir_filter_xxx_0_0, '0']
- [bladeRF_source_0, '1', qtgui_sink_x_1_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_0_0, '0']
- [blocks_integrate_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_integrate_xx_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_integrate_xx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_sink_x_1_1_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', blocks_stream_to_vector_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', qtgui_sink_x_1_1, '0']

metadata:
  file_format: 1
